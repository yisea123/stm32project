# Keil uVision project boot_stm32f1_keil.uvprojx, settings and files
target boot_stm32f1_keil (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: boot_stm32f1_keil +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER,STM32F103xB, STM32F10X_MD, NO_PRINTF, HW_OLIMEX
  c misc: --C99
  c include: ./STM32F1xx_HAL_Driver/Inc;./STM32F1xx_HAL_Driver/Inc/Legacy;./coappl;./CMSIS/Device/ST/STM32F1xx/Include;./CMSIS/Include;../../colib/inc;../../codrv/stm32
  library: MicroLIB
  memory RVCT4: ROM 0x8004200 size 0x1be00
  memory RVCT9: RAM 0x20000010 size 0x4ff0
  memory RVCT10: RAM 0x20000000 size 0x10
  group CMSIS
    ./: system_stm32f1xx.c startup_stm32f103xb.s
  group STM32F1xx_HAL_Driver
    ./STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_it.c
  group coappl
    ./coappl/: fwupdate.c gen_objdict.c main.c
  group codrv
    ../../codrv/stm32/: cpu_stm32f1_keil.c codrv_bxcan.c codrv_canbittiming.c codrv_error.c
  group colib
    ../../colib/src/: co_candebug.c co_cobhandler.c co_commtask.c co_dynod.c co_emcy.c co_errctrl.c co_event.c co_led.c co_lss.c co_nmt.c co_odaccess.c co_pdo.c co_queue.c co_sdoserv.c co_sleep.c co_stackinit.c co_store.c co_sync.c co_timer.c co_user.c
software components: CMSIS:CORE 4.1.0
