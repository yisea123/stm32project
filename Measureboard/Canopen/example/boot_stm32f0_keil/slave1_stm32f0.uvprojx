# Keil uVision project slave1_stm32f0.uvprojx, settings and files
target boot_slave1 (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: boot_slave1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F072xB, NO_PRINTF, USE_STDPERIPH_DRIVER, USE_HAL_DRIVER,BOOT
  c include: .;..\..\colib\inc;..\..\codrv\stm32;.\STM32F0xx_HAL_Driver\Inc;.\CMSIS\Device\ST\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8004010 size 0x1bff0
  memory RVCT9: RAM 0x20000110 size 0x3ef0
  memory RVCT10: RAM 0x20000000 size 0x110
  group colib
    ../../colib/src/: co_cobhandler.c co_commtask.c co_emcy.c co_errctrl.c co_event.c co_led.c co_nmt.c co_odaccess.c co_pdo.c co_queue.c co_sdoserv.c co_stackinit.c co_store.c co_sync.c co_timer.c
  group codrv
    ../../codrv/stm32/: codrv_bxcan.c codrv_canbittiming.c codrv_error.c cpu_stm32f0_keil.c
  group application
    ./: gen_objdict.c main.c fwupdate.c
  group HAL
    ./STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c
  group system
    ./: system_stm32f0xx.c startup_stm32f072xb.s
target slave1 (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.3.0
  cpu: as above
  output: slave1_stm32f0
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F072xB, NO_PRINTF, USE_STDPERIPH_DRIVER, USE_HAL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 3.40.0
