# IAR project slave1_stm32l476_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\colib\inc; ..\..\colib\src; ..\..\codrv\stm32; appl; CMSIS\Include; CMSIS\Device\ST\STM32L4xx\Include; CMSIS\Device\ST\STM32L4xx\Source\Templates; CMSIS\Device\ST\STM32L4xx\Source\Templates\gcc; STM32L4xx_HAL_Driver\Inc; STM32L4xx_HAL_Driver\Inc\Legacy; STM32L4xx_HAL_Driver\Src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: slave1_stm32l476_iar.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32L476xx; USE_HAL_DRIVER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group appl
    appl/: gen_define.h gen_indication.h gen_objdict.c main.c
  group CMSIS/Device/ST/STM32L4xx/Include
    CMSIS/Device/ST/STM32L4xx/Include/: stm32l431xx.h stm32l432xx.h stm32l433xx.h stm32l442xx.h stm32l443xx.h stm32l471xx.h stm32l475xx.h stm32l476xx.h stm32l485xx.h stm32l486xx.h stm32l4xx.h system_stm32l4xx.h
  group CMSIS/Device/ST/STM32L4xx/Source/Templates
    CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group CMSIS/Device/ST/STM32L4xx/Source/Templates/iar
    CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l476xx.s
  group CMSIS/Include
    CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group codrv/stm32
    ../../codrv/stm32/: codrv_bxcan.c codrv_bxcan.h codrv_canbittiming.c codrv_error.c codrv_error.h cpu_stm32.h cpu_stm32l4_hal.c
  group colib/inc
    ../../colib/inc/: co_candebug.h co_canopen.h co_cfgman.h co_cob.h co_commtask.h co_datatype.h co_drv.h co_edsparse.h co_emcy.h co_flyingmaster.h co_gfc.h co_led.h co_lss.h co_manager.h co_network.h co_nmt.h co_odaccess.h co_odindex.h co_pdo.h co_sdo.h co_sleep.h co_srd.h co_srdo.h co_store.h co_sync.h co_time.h co_timer.h co_usdo.h co_user.h
  group colib/src
    ../../colib/src/: co_candebug.c co_cobhandler.c co_commtask.c co_dynod.c co_emcy.c co_errctrl.c co_event.c co_led.c co_lss.c co_nmt.c co_nmtslave.c co_odaccess.c co_pdo.c co_queue.c co_sdoserv.c co_sleep.c co_stackinit.c co_store.c co_sync.c co_timer.c co_user.c ico_candebug.h ico_cobhandler.h ico_commtask.h ico_dynod.h ico_emcy.h ico_event.h ico_gfc.h ico_indication.h ico_j1939.h ico_led.h ico_lss.h ico_network.h ico_nmt.h ico_odaccess.h ico_pdo.h ico_queue.h ico_sdo.h ico_sdoclient.h ico_sdoserver.h ico_sleep.h ico_srd.h ico_srdo.h ico_store.h ico_sync.h ico_time.h ico_timer.h ico_usdo.h ico_usdoclient.h ico_usdoserver.h ico_user.h
  group STM32L4xx_HAL_Driver/Inc
    STM32L4xx_HAL_Driver/Inc/: mxconstants.h stm32l4xx_hal.h stm32l4xx_hal_can.h stm32l4xx_hal_conf.h stm32l4xx_hal_cortex.h stm32l4xx_hal_def.h stm32l4xx_hal_dma.h stm32l4xx_hal_flash.h stm32l4xx_hal_flash_ex.h stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_gpio.h stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_i2c.h stm32l4xx_hal_i2c_ex.h stm32l4xx_hal_pwr.h stm32l4xx_hal_pwr_ex.h stm32l4xx_hal_rcc.h stm32l4xx_hal_rcc_ex.h stm32l4xx_hal_tim.h stm32l4xx_hal_tim_ex.h stm32l4xx_it.h
  group STM32L4xx_HAL_Driver/Inc/Legacy
    STM32L4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group STM32L4xx_HAL_Driver/Src
    STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_can.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_msp.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
