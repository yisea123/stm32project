# Keil uVision project slave1_stm32l4_keil.uvprojx, settings and files
target slave1_stm32l4_keil (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: slave1_stm32l4_keil
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c misc: --C99
  c include: .\STM32L4xx_HAL_Driver\Inc;.\STM32L4xx_HAL_Driver\Inc\Legacy;.\CMSIS\Device\ST\STM32L4xx\Include;.\CMSIS\Include;..\..\colib\inc;.\coappl;..\..\codrv\stm32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group CMSIS
    ./CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group startup
    ./CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l476xx.s
  group coappl
    ./coappl/: gen_define.h gen_indication.h gen_objdict.c main.c
  group STM32L4xx_HAL_Driver
    ./STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_can.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c
  group colib
    ../../colib/src/: co_candebug.c co_cobhandler.c co_commtask.c co_dynod.c co_emcy.c co_errctrl.c co_event.c co_led.c co_lss.c co_nmt.c co_odaccess.c co_pdo.c co_queue.c co_sdoserv.c co_sleep.c co_stackinit.c co_store.c co_sync.c co_timer.c
  group codrv
    ../../codrv/stm32/: codrv_bxcan.c codrv_canbittiming.c codrv_error.c cpu_stm32l4_hal.c
software components: CMSIS:CORE 4.1.0
