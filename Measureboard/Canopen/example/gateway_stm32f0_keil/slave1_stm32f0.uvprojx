# Keil uVision project slave1_stm32f0.uvprojx, settings and files
target gateway_stm32f0 (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: gateway_stm32f0
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB, NO_PRINTF, USE_STDPERIPH_DRIVER, USE_HAL_DRIVER,  MQ_PROTOKOLL
  c include: .;..\..\colib\inc;..\..\codrv\stm32;.\Drivers\STM32F0xx_HAL_Driver\Inc;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\ST\STM32F0xx\Include;.\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group colib
    ../../colib/src/: co_cobhandler.c co_commtask.c co_emcy.c co_errctrl.c co_event.c co_led.c co_nmt.c co_odaccess.c co_pdo.c co_queue.c co_sdoserv.c co_stackinit.c co_store.c co_sync.c co_timer.c
  group codrv
    ../../codrv/stm32/: codrv_bxcan.c codrv_canbittiming.c codrv_error.c cpu_stm32f0_keil.c
  group application
    ./: gen_objdict.c main.c stm32f0xx_hal_msp.c stm32f0xx_it.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c gateway.c gateway_emtas.c
  group Middlewares/USB_Device_Library
    ./Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ./Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Drivers/STM32F0xx_HAL_Driver
    ./Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_can.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ./: system_stm32f0xx.c startup_stm32f072xb.s
target gateway_stm32f0_emtas (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: as above
  output: gateway_stm32f0
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB, NO_PRINTF, USE_STDPERIPH_DRIVER, USE_HAL_DRIVER,EMTAS_PROTOKOLL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 3.40.0
