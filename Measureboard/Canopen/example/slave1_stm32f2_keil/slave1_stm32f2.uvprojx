# Keil uVision project slave1_stm32f2.uvprojx, settings and files
target Target (ARM-ADS)
  device: STM32F207ZETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: slave1_stm32f2
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\slave1_stm32f2_keil;..\..\colib\inc;..\..\colib\src;..\..\codrv\stm32;..\..\codrv\common
  memory RVCT5: ROM 0x8004200 size 0x7ab00
  memory RVCT6: RAM 0x20000000 size 0x10
  memory RVCT9: RAM 0x20000010 size 0x1fff0
  group Source
    ./: main.c gen_objdict.c fwupdate.c
  group colib
    ../../colib/src/: co_cobhandler.c co_commtask.c co_emcy.c co_errctrl.c co_event.c co_led.c co_nmt.c co_nmtslave.c co_odaccess.c co_pdo.c co_queue.c co_stackinit.c co_timer.c co_sdoserv.c co_store.c co_time.c
  group codrv
    ../../codrv/stm32/: codrv_bxcan.c codrv_canbittiming.c codrv_error.c cpu_stm32f2_keil.c
  group Output
    ./Listings/: slave1_stm32f2.map
  group colib_mutex
    ./: colib_mutex.c colib_mutex.h
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Device:STM32Cube Framework:Classic 1.0.1, Device:STM32Cube HAL:CAN 1.0.1, Device:STM32Cube HAL:Common 1.0.1, Device:STM32Cube HAL:Cortex 1.0.1, Device:STM32Cube HAL:GPIO 1.0.1, Device:STM32Cube HAL:RCC 1.0.1, Device:Startup 2.0.1
