# Keil uVision project slave1_stm32f103.uvprojx, settings and files
target stm32_olimex (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_olimex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, NO_PRINTF, HW_OLIMEX
  c include: ..\..\colib\src;..\..\colib\inc;..\..\codrv\stm32;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group setup
    ./: Setup.c STM32DBG.ini
  group source
    ./: main.c gen_objdict.c
  group information
    ./: stm32_olimex.map
  group printf
    ./: Retarget.c Serial.c
  group driver
    ../../codrv/stm32/: codrv_bxcan.c cpu_stm32.c codrv_error.c
  group canopen
    ../../colib/src/: co_cobhandler.c co_commtask.c co_emcy.c co_errctrl.c co_nmt.c co_odaccess.c co_pdo.c co_queue.c co_sdoserv.c co_sync.c co_timer.c co_led.c co_event.c co_store.c co_stackinit.c
  group Bootloader
    ./: fwupdate.c
target stm32_released (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_olimex
  c flags: Optim=3 OneElfS=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, NO_PRINTF, HW_OLIMEX
  c include: ..\..\colib\src;..\..\colib\inc;..\..\codrv\stm32;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target stm32_boot (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: as above
  output: stm32_boot +hex
  c flags: Optim=3 OneElfS=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, NO_PRINTF, HW_OLIMEX,BOOT
  c include: ..\..\colib\src;..\..\colib\inc;..\..\codrv\stm32;.
  library: MicroLIB
  memory RVCT4: ROM 0x8004200 size 0x1be00
  memory RVCT9: RAM 0x20000010 size 0x4ff0
  memory RVCT10: RAM 0x20000000 size 0x10
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
